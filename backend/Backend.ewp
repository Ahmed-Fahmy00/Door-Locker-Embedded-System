# IAR project Backend.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C123GH6PM
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295\inc; C:\ti\TivaWare_C_Series-2.2.0.295\driverlib; C:\ti\TivaWare_C_Series-2.2.0.295; MCAL; lib; components; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group application
    application/: buzzer_service.c buzzer_service.h door_controller.c door_controller.h eeprom_handler.c eeprom_handler.h uart_commands.c uart_commands.h uart_handler.c uart_handler.h uart_protocol.c uart_protocol.h
  group HAL
    HAL/: buzzer.c buzzer.h motor.c motor.h status_led.c status_led.h timeout.c timeout.h
  group lib
    lib/: startup_ewarm.c tm4c123gh6pm.h
  group MCAL
    MCAL/: dio.c dio.h gptm.c gptm.h systick.c systick.h uart.c uart.h
